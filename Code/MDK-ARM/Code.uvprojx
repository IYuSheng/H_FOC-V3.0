# Keil uVision project Code.uvprojx, settings and files
target Code (6240000::V6.24::ARMCLANG)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: H_FOC_V3.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G431xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\APP;..\MID
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c cordic.c fdcan.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_fdcan.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group APP
    ../APP/: Config.h foc_control.c foc_control.h foc_encoder.c foc_encoder.h FOC_Init.c FOC_Init.h foc_setting.c foc_setting.h foc_sys.c foc_sys.h
  group MID
    ../MID/: foc_conversion.c foc_conversion.h foc_filter.c foc_filter.h foc_ladrc.c foc_ladrc.h foc_vibration_sweep.c foc_vibration_sweep.h foc_cogging_compensation.c foc_cogging_compensation.h foc_communication.c foc_communication.h foc_prase.c foc_prase.h foc_trapezoid_planner.c foc_trapezoid_planner.h foc_trajectory_planning.c foc_trajectory_planning.h foc_encoder_calibration.c foc_encoder_calibration.h foc_mechanical_param.c foc_mechanical_param.h
software components: CMSIS:CORE 6.1.0
